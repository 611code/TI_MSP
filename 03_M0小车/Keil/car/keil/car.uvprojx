# Keil uVision project car.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\;..\Bsp\BMI088\inc;..\Bsp\BMI088\Klman_Yaw;..\Bsp\Button;..\Bsp\Contorl;..\Bsp\Encoder;..\Bsp\gray;..\Bsp\Motor;..\Bsp\Oled;..\Bsp\Pid;..\Bsp\Task_manage;..\Bsp\UART
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group oled
    ../Bsp/Oled/: app_oled.c hw_oled.c
  group bmi088
    ../Bsp/BMI088/: BMI088driver.c BMI088Middleware.c
    ../Bsp/BMI088/Klman_Yaw/: ekf_yaw.c
  group button
    ../Bsp/Button/: multi_button.c multi_button_user.c
  group motor
    ../Bsp/Motor/: Bsp_Motor.c
  group encoder
    ../Bsp/Encoder/: encoder_user.c hw_encoder.c
  group gray
    ../Bsp/gray/: gray_app.c hardware_iic.c IIC.c
  group pid
    ../Bsp/Pid/: pid.c pid_user.c
  group scheduler
    ../Bsp/Task_manage/: scheduler.c system.c task_manage.c bsp_system.h
  group uart
    ../Bsp/UART/: ringbuffer.c uart_app.c
